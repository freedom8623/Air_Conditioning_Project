# Keil uVision project 空调控制板.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC12C5A60S2 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0xEFFF) CLOCK(45000000) MODP2
  output: 空调控制板 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\Driver;C:\Keil_v5\C51\INC\STC
  group User
    ./: main.c
  group Driver
    ./Driver/DS18B20/: bes_ds18b20.c
    ./Driver/IR/: IR.c
    ./Driver/LED/: LED.C
    ./Driver/seg/: seg.c
    ./Driver/timer/: timer.c
    ./Driver/Uart/: Uart.c
    ./Driver/adc/: adc.c
