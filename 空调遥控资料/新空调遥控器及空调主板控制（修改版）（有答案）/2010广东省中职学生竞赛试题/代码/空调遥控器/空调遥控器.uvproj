# Keil uVision project 空调遥控器.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC11F02E Series STC
  cpu: IRAM(0-0xFF) IROM(0-0x7FF) CLOCK(45000000)
  output: 空调遥控器 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\Driver;D:\WorkSoftware\Keil5_C51\C51\INC\STC
  group User
    ./: main.c
  group Driver
    ./Driver/KEY/: key.c
    ./Driver/IR/: IR.c
